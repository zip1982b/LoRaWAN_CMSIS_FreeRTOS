# IAR project LoRaWAN_CMSIS_FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ; inc\; CMSIS\inc\; FreeRTOS\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: inc\
  OBJCOPY.OOCOutputFile: LoRaWAN_CMSIS_FreeRTOS.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: RELEASE
  group (top)
    ./: clock.c gpio.c main.c modemRHF78-052.c RingFIFO.c uart.c
  group CMSIS
    CMSIS/: startup_stm32f103xb.s
  group CMSIS/inc
    CMSIS/inc/: core_cm3.h core_cmFunc.h core_cmInstr.h stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
  group CMSIS/src
    CMSIS/src/: system_stm32f1xx.c
  group FreeRTOS/src
    FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c portasm.s queue.c stream_buffer.c tasks.c timers.c
  group inc
    inc/: clock.h FreeRTOSConfig.h gpio.h modemRHF78-052.h RingFIFO.h uart.h
